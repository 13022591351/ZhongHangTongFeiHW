# Repository 13022591351/ZhongHangTongFeiHW

File README.md:

# ZhongHangTongFeiHW
中航通飞EVTOL项目 硬件设计

## KiCad design EquipmentBox1/EquipmentBox1.kicad_pcb

Parts:
J1, J2, J3, J4: UAC16-9
J5, J6, J7, J8: UAC16-8
J9, J10: UAV20-5; UAC20-5
J11: UAC28-2
J12: 430450612
J13: 430452212
J14: 430452412
J15, J16: XT60F; AMASS_XT60-F_1x02_P7.20mm_Vertical
R1, R2, R3, R4: 1K; R_0402_1005Metric

Connections:
+3.3V: J1.8, J2.8, J3.8, J4.8, J13.18
+5V: J1.1, J1.5, J2.1, J2.5, J3.1, J3.5, J4.1, J4.5, J8.1, J8.7, J14.14, J14.16, J14.18, J14.20, J14.24
+12V: J14.13
/AD1_U3: J1.6, J13.12, R1.2
/AD1_U4: J2.6, J13.13, R2.2
/AD1_U7: J3.6, J13.14, R3.2
/AD1_U8: J4.6, J13.15, R4.2
/AD2_U3: J8.3, J13.16
/AD2_U4: J8.5, J13.17
/MCU2_CAN2_H+: J9.5, J12.5
/MCU2_CAN2_L-: J9.3, J12.6
/MCU3_CAN2_H+: J10.5, J12.2
/MCU3_CAN2_L-: J10.3, J12.3
/MOTOR3: J1.7, J13.8
/MOTOR4: J2.7, J13.9
/MOTOR7: J3.7, J13.19
/MOTOR8: J4.7, J13.20
/PWM3_Y-A: J1.3, J14.15
/PWM3_Z-B: J1.2, J14.3
/PWM4_Y-A: J2.3, J14.17
/PWM4_Z-B: J2.2, J14.5
/PWM7_Y-A: J3.3, J14.19
/PWM7_Z-B: J3.2, J14.7
/PWM8_Y-A: J4.3, J14.21
/PWM8_Z-B: J4.2, J14.9
/RX+: J5.6, J14.10
/RX-: J5.5, J14.11
/TX+: J5.2, J14.22
/TX-: J5.3, J14.23
/V_28V: J5.1, J9.1, J10.1, J11.1, J15.2, J16.2
/V_GND: J5.4, J9.4, J10.4, J11.2, J15.1, J16.1
GND: J1.4, J1.9, J2.4, J2.9, J3.4, J3.9, J4.4, J4.9, J5.8, J8.2, J8.6, J9.2, J10.2, J12.1, J12.4, J13.1, J13.2, J13.3, J13.4, J13.5, J13.6, J13.7, J14.1, J14.2, J14.4, J14.6, J14.8, J14.12, R1.1, R2.1, R3.1, R4.1

Notes on the sheet:
右机翼
转发板右
飞控右
倾转3-4
大气机
电调8
电调4
电调7
采集板右
电调3

Board: 4 copper layers, 272.4 x 41.0 mm, 20 parts (5 on the bottom side), 31 nets.

## KiCad design EquipmentBoxRight_V2/EquipmentBoxRight_V2.kicad_pcb

Board: 4 copper layers, 272.5 x 41.0 mm, 44 parts (5 on the bottom side), 38 nets.

Parts:
C1, C3, C9, C10: 50V 22uF; CP_EIA-7343-31_Kemet-D
C2, C5, C7, C8: 47uF 50V; C_1206_3216Metric
C4: 430pF 50V; C_0402_1005Metric
C6: 100nF 50V; C_0402_1005Metric
D1, D2, D3: SMCJ30CA; D_SMC
D4: SS56; D_SMA
IC1: TPS82130SILR
J1: UAC28-2
J2, J9, J10, J11: UAC16-8
J3, J4: UAV20-5; UAC20-5
J5, J6, J7, J8: UAC16-9
J12, J13: XT60F; AMASS_XT60-F_1x02_P7.20mm_Vertical
J14: 430452412
J15: 430452212
J16: 430450612
L1: 22uH 7A; L_Sunlord_MWSA1206S-100
R1, R2, R3, R4: 1K; R_0402_1005Metric
R5, R6, R8: 100K; R_0402_1005Metric
R7: 523K; R_0402_1005Metric
R9: 10K; R_0402_1005Metric
R10: 1.13K; R_0402_1005Metric
U1: TPS5450DDA; TI_SO-PowerPAD-8_ThermalVias
U2: LP5912-3.3DRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias

Connections:
+3.3V: C7.1, J5.8, J6.8, J7.8, J8.8, J15.18, R5.2, U2.1 (OUT)
+5V: C5.1, C8.1, IC1.4 (VOUT), IC1.5 (VDUT), J5.1, J5.5, J6.1, J6.5, J7.1, J7.5, J8.1, J8.5, J9.1, J9.7, J14.14, J14.16, J14.18, J14.20, J14.24, R6.2, R7.2, U2.4 (EN), U2.6 (IN)
+12V: C2.1, C9.1, C10.1, IC1.1 (EN), IC1.2 (VIN), J14.13, L1.2, R9.2
+28V: C1.1, C3.1, D1.1 (A1), D2.1 (A1), D3.1 (A1), J1.1, J2.1, J3.1, J4.1, J12.2, J13.2, U1.7 (VIN)
/AD1_U3: J5.6, J15.12, R1.2
/AD1_U4: J6.6, J15.13, R2.2
/AD1_U7: J7.6, J15.14, R3.2
/AD1_U8: J8.6, J15.15, R4.2
/AD2_U3: J9.3, J15.16
/AD2_U4: J9.5, J15.17
/BOOT: C6.1, U1.1 (BOOT)
/FB: R9.1, R10.1, U1.4 (VSENSE)
/MCU2_CAN2_H+: J3.5, J16.5
/MCU2_CAN2_L-: J3.3, J16.6
/MCU3_CAN2_H+: J4.5, J16.2
/MCU3_CAN2_L-: J4.3, J16.3
/MOTOR3: J5.7, J15.8
/MOTOR4: J6.7, J15.9
/MOTOR7: J7.7, J15.19
/MOTOR8: J8.7, J15.20
/PH: C6.2, D4.1 (K), L1.1, U1.8 (PH)
/PWM3_Y-A: J5.3, J14.15
/PWM3_Z-B: J5.2, J14.3
/PWM4_Y-A: J6.3, J14.17
/PWM4_Z-B: J6.2, J14.5
/PWM7_Y-A: J7.3, J14.19
/PWM7_Z-B: J7.2, J14.7
/PWM8_Y-A: J8.3, J14.21
/PWM8_Z-B: J8.2, J14.9
/RX+: J2.6, J14.10
/RX-: J2.5, J14.11
/TX+: J2.2, J14.22
/TX-: J2.3, J14.23
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C7.2, C8.2, C9.2, C10.2, D1.2 (A2), D2.2 (A2), D3.2 (A2), D4.2 (A), IC1.3 (GND), IC1.9 (EP), J1.2, J2.4, J2.8, J3.2, J3.4, J4.2, J4.4, J5.4, J5.9, J6.4, J6.9, J7.4, J7.9, J8.4, J8.9, J9.2, J9.6, J12.1, J13.1, J14.1, J14.2, J14.4, J14.6, J14.8, J14.12, J15.1, J15.2, J15.3, J15.4, J15.5, J15.6, J15.7, J16.1, J16.4, R1.1, R2.1, R3.1, R4.1, R8.2, R10.2, U1.6 (GND), U1.9 (GNDPAD), U2.5 (GND), U2.7 (EP)
unnamed: IC1.6 (FB), R7.1, R8.1
unnamed: IC1.7 (PG), R6.1
unnamed: C4.2, IC1.8 (SS/TR)
unnamed: R5.1, U2.3 (PG)

## KiCad design EquipmentBox2/EquipmentBox2.kicad_pcb

Parts:
J1, J2, J3, J4, J5, J6: UAC16-8
J7, J8, J9, J15: UAC16-9
J10, J11: UAC20-5
J12: 430452412
J13: 430452212
J14: 430450612
J16: XT60M; AMASS_XT60-M_1x02_P7.20mm_Vertical
J17: XT60F; AMASS_XT60-F_1x02_P7.20mm_Vertical
R1, R2, R3, R4: 1K; R_0402_1005Metric

Connections:
+3.3V: J7.8, J8.8, J9.8, J13.18, J15.8
+5V: J6.1, J6.7, J7.1, J7.5, J8.1, J8.5, J9.1, J9.5, J12.14, J12.16, J12.18, J12.20, J12.22, J15.1, J15.5
+12V: J4.1, J12.13
/AD1_U1: J7.6, J13.12, R1.2
/AD1_U2: J8.6, J13.13, R2.2
/AD1_U5: J13.14, J15.6, R3.2
/AD1_U6: J9.6, J13.15, R4.2
/AD2_U1: J6.3, J13.16
/AD2_U2: J6.5, J13.17
/CAN1_H+: J4.7, J13.21
/CAN1_L-: J4.6, J13.22
/CAN2_H+: J1.7, J12.10
/CAN2_L-: J1.6, J12.11
/MCU1_CAN2_H+: J11.5, J14.2
/MCU1_CAN2_L-: J11.3, J14.3
/MOTOR1: J7.7, J13.8
/MOTOR2: J8.7, J13.9
/MOTOR5: J13.19, J15.7
/MOTOR6: J9.7, J13.20
/PWM1_Y-A: J7.3, J12.15
/PWM1_Z-B: J7.2, J12.3
/PWM2_Y-A: J8.3, J12.17
/PWM2_Z-B: J8.2, J12.5
/PWM5_Y-A: J12.19, J15.3
/PWM5_Z-B: J12.7, J15.2
/PWM6_Y-A: J9.3, J12.21
/PWM6_Z-B: J9.2, J12.9
/V_28V: J11.1, J16.1, J17.1
/V_GND: J11.4, J16.2, J17.2
GND: J1.5, J4.4, J6.2, J6.6, J7.4, J7.9, J8.4, J8.9, J9.4, J9.9, J11.2, J12.1, J12.2, J12.4, J12.6, J12.8, J13.1, J13.2, J13.3, J13.4, J13.5, J13.6, J13.7, J13.10, J14.1, J15.4, J15.9, R1.1, R2.1, R3.1, R4.1

Notes on the sheet:
调试口
电调2
转发板左
飞控左
电调1
电调5
电调6
采集板左
左机翼
倾转1-2
雷达、电池接口

Board: 4 copper layers, 272.4 x 41.0 mm, 21 parts (5 on the bottom side), 30 nets.

## KiCad design ICTest/ICTest.kicad_pcb

Parts:
C1, C2: 100nF 50V; C_0402_1005Metric
D1, D2: D_TVS; D_SOD-323
J1, J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1, R3, R4, R5: 10K; R_0402_1005Metric
R2: 1K; R_0402_1005Metric
R6: 15K; R_0402_1005Metric
R7: 120R; R_0603_1608Metric
R8, R9: 0R; R_0402_1005Metric
U1: MAX490E; SO-8_3.9x4.9mm_P1.27mm
U2: LM2904; SO-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, C2.1, J1.2, J2.2, J2.5, R1.1, R4.1, U1.1 (VCC), U2.8 (V+)
/PT1000_ADC: J2.6, R5.1, R6.2
/PT1000_IN: J1.5, R4.2, U2.3 (+)
/PWM_IN: J2.3, U1.3 (DI)
/PWM_Y_A+: D2.1 (A1), J1.4, R9.1
/PWM_Z_B-: D1.1 (A1), J1.3, R8.1
GND: C1.2, C2.2, D1.2 (A2), D2.2 (A2), J1.1, J1.6, J2.1, J2.4, R2.1, R6.1, U1.4 (GND), U2.4 (V-)
unnamed: R3.2, R5.2, U2.1
unnamed: R7.2, R9.2, U1.5 (Y)
unnamed: R7.1, R8.2, U1.6 (Z)
unnamed: R1.2, R2.2, R3.1, U2.2 (-)

Board: 2 copper layers, 30.0 x 17.3 mm, 17 parts (0 on the bottom side), 11 nets.

## KiCad design F105X3CAN/F105X3CAN.kicad_pcb

Board: 4 copper layers, 73.0 x 55.0 mm, 134 parts (0 on the bottom side), 91 nets.

Parts:
C1, C2: 10uF 50V; C_1206_3216Metric
C3, C4: 220uF 16V; C_1206_3216Metric
C7, C11, C12, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C32, C33, C34, C35, C36, C37, C38, C39: 100nF 50V; C_0402_1005Metric
C8, C9, C30, C31, C42, C43: 16pF 50V; C_0402_1005Metric
C10, C13, C28, C29, C40, C41: 1uF 16V; C_0805_2012Metric
D1, D2: SS56; D_SMA
D3, D6, D8: LED1; LED_0603_1608Metric
D4, D7, D9: LED2; LED_0603_1608Metric
D5: LED; LED_0603_1608Metric
D10: SMAJ30CA; D_SMA
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
J1: CAN_ALL; JST_GH_BM06B-GHS-TBT_1x06-1MP_P1.25mm_Vertical
J2, J6, J10: DBG; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J3, J8, J12: CAN1; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J4, J9, J13: CAN2; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J5, J7, J11: TTL; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
L1: 10uH 5A; L_6.3x6.3_H3
L2, L3, L4: MLF2012C101KT000; L_0805_2012Metric
R1, R4, R5, R8, R9, R19, R20, R21, R22, R31, R32, R33, R34: 10K; R_0402_1005Metric
R2: 5.9K; R_0402_1005Metric
R3, R14, R15, R27, R28, R39, R40: 120R; R_0603_1608Metric
R6, R7, R13, R16, R23, R24, R25, R26, R35, R36, R37, R38: 22R; R_0402_1005Metric
R10, R11, R12, R17, R18, R29, R30: 1K; R_0402_1005Metric
R41, R42, R43, R44, R45, R46: 0R; R_0402_1005Metric
RV1, RV2, RV3: 0-500R; Potentiometer_Bourns_TC33X_Vertical
U1: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias
U2, U5, U8: STM32F105R8Tx; LQFP-64_10x10mm_P0.5mm
U3, U4, U6, U7, U9, U10: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
Y1, Y2, Y3: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C3.1, C4.1, C10.1, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.1, C29.1, C32.2, C33.2, C34.2, C35.2, C36.2, C38.2, C39.2, C40.1, C41.1, J2.2, J5.2, J6.2, J7.2, J10.2, J11.2, L1.2, L2.1, L3.1, L4.1, R1.2, R4.1, R10.2, R11.2, R12.2, R17.2, R18.2, R19.1, R29.2, R30.2, R31.1, U2.1 (VBAT), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U3.3 (VCC), U4.3 (VCC), U5.1 (VBAT), U5.19 (VDD), U5.32 (VDD), U5.48 (VDD), U5.64 (VDD), U6.3 (VCC), U7.3 (VCC), U8.1 (VBAT), U8.19 (VDD), U8.32 (VDD), U8.48 (VDD), U8.64 (VDD), U9.3 (VCC), U10.3 (VCC)
+24V: D1.2 (A), J1.3, J1.4
/BOOT: C7.1, U1.1 (BOOT)
/CAN_ALL_H+: J1.5, R3.1, R41.1, R44.1, R46.1
/CAN_ALL_L-: J1.6, R3.2, R42.1, R43.1, R45.1
/CAN_CORE1_H+: J3.3, R14.1, R41.2, U3.7 (CANH)
/CAN_CORE1_L-: J3.4, R14.2, R42.2, U3.6 (CANL)
/CAN_CORE2_H+: J8.3, R27.1, R44.2, U6.7 (CANH)
/CAN_CORE2_L-: J8.4, R27.2, R43.2, U6.6 (CANL)
/CAN_CORE3_H+: J12.3, R39.1, R46.2, U9.7 (CANH)
/CAN_CORE3_L-: J12.4, R39.2, R45.2, U9.6 (CANL)
/CORE1/+3.3VA: C19.2, L2.2, U2.13 (VDDA)
/CORE1/CAN1_RX: U2.61 (PB8), U3.4 (R)
/CORE1/CAN1_TX: U2.62 (PB9), U3.1 (D)
/CORE1/CAN2_H+: J4.3, R15.1, RV1.1, U4.7 (CANH)
/CORE1/CAN2_L-: J4.4, R15.2, RV1.2, U4.6 (CANL)
/CORE1/CAN2_RX: U2.57 (PB5), U4.4 (R)
/CORE1/CAN2_TX: U2.58 (PB6), U4.1 (D)
/CORE1/DBG_CLK: R7.2, U2.49 (PA14)
/CORE1/DBG_DIO: R6.2, U2.46 (PA13)
/CORE1/OSC_IN: C9.2, U2.5 (PD0), Y1.3
/CORE1/OSC_OUT: C8.2, U2.6 (PD1), Y1.1
/CORE1/UART3_RX: R13.2, U2.30 (PB11)
/CORE1/UART3_TX: R16.2, U2.29 (PB10)
/CORE2/+3.3VA: C25.2, L3.2, U5.13 (VDDA)
/CORE2/CAN1_RX: U5.61 (PB8), U6.4 (R)
/CORE2/CAN1_TX: U5.62 (PB9), U6.1 (D)
/CORE2/CAN2_H+: J9.3, R28.1, RV2.1, U7.7 (CANH)
/CORE2/CAN2_L-: J9.4, R28.2, RV2.2, U7.6 (CANL)
/CORE2/CAN2_RX: U5.57 (PB5), U7.4 (R)
/CORE2/CAN2_TX: U5.58 (PB6), U7.1 (D)
/CORE2/DBG_CLK: R24.2, U5.49 (PA14)
/CORE2/DBG_DIO: R23.2, U5.46 (PA13)
/CORE2/OSC_IN: C30.2, U5.5 (PD0), Y2.3
/CORE2/OSC_OUT: C31.2, U5.6 (PD1), Y2.1
/CORE2/UART3_RX: R25.2, U5.30 (PB11)
/CORE2/UART3_TX: R26.2, U5.29 (PB10)
/CORE3/+3.3VA: C37.2, L4.2, U8.13 (VDDA)
/CORE3/CAN1_RX: U8.61 (PB8), U9.4 (R)
/CORE3/CAN1_TX: U8.62 (PB9), U9.1 (D)
/CORE3/CAN2_H+: J13.3, R40.1, RV3.1, U10.7 (CANH)
/CORE3/CAN2_L-: J13.4, R40.2, RV3.2, U10.6 (CANL)
/CORE3/CAN2_RX: U8.57 (PB5), U10.4 (R)
/CORE3/CAN2_TX: U8.58 (PB6), U10.1 (D)
/CORE3/DBG_CLK: R36.2, U8.49 (PA14)
/CORE3/DBG_DIO: R35.2, U8.46 (PA13)
/CORE3/OSC_IN: C42.2, U8.5 (PD0), Y3.3
/CORE3/OSC_OUT: C43.2, U8.6 (PD1), Y3.1
/CORE3/UART3_RX: R37.2, U8.30 (PB11)
/CORE3/UART3_TX: R38.2, U8.29 (PB10)
/FB: R1.1, R2.1, U1.4 (VSENSE)
/PH: C7.2, D2.1 (K), L1.1, U1.8 (PH)
/VIN: C1.1, C2.1, D1.1 (K), D10.2 (A2), U1.7 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.2, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.2, C29.2, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.2, C41.2, C42.1, C43.1, D2.2 (A), D5.1 (K), D10.1 (A1), H1.1, H2.1, H3.1, H4.1, J1.1, J1.2, J1.MP (MountPin), J2.1, J2.MP (MountPin), J3.1, J3.MP (MountPin), J4.1, J4.MP (MountPin), J5.1, J5.MP (MountPin), J6.1, J6.MP (MountPin), J7.1, J7.MP (MountPin), J8.1, J8.MP (MountPin), J9.1, J9.MP (MountPin), J10.1, J10.MP (MountPin), J11.1, J11.MP (MountPin), J12.1, J12.MP (MountPin), J13.1, J13.MP (MountPin), R2.2, R5.1, R8.1, R9.1, R20.1, R21.1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
unnamed: D3.2 (A), R10.1
unnamed: D3.1 (K), U2.2 (PC13)
unnamed: D4.2 (A), R11.1
unnamed: D4.1 (K), U2.3 (PC14)
unnamed: D5.2 (A), R12.1
unnamed: D6.2 (A), R17.1
unnamed: D6.1 (K), U5.2 (PC13)
unnamed: D7.2 (A), R18.1
unnamed: D7.1 (K), U5.3 (PC14)
unnamed: D8.2 (A), R29.1
unnamed: D8.1 (K), U8.2 (PC13)
unnamed: D9.2 (A), R30.1
unnamed: D9.1 (K), U8.3 (PC14)
unnamed: J2.3, R6.1
unnamed: J2.4, R7.1
unnamed: J5.3, R13.1
unnamed: J5.4, R16.1
unnamed: J6.3, R23.1
unnamed: J6.4, R24.1
unnamed: J7.3, R25.1
unnamed: J7.4, R26.1
unnamed: J10.3, R35.1
unnamed: J10.4, R36.1
unnamed: J11.3, R37.1
unnamed: J11.4, R38.1
unnamed: R5.2, U2.60 (BOOT0)
unnamed: R4.2, U2.7 (NRST)
unnamed: R9.2, U2.27 (PB1)
unnamed: R8.2, U2.28 (PB2)
unnamed: R20.2, U5.60 (BOOT0)
unnamed: R19.2, U5.7 (NRST)
unnamed: R21.2, U5.27 (PB1)
unnamed: R22.2, U5.28 (PB2)
unnamed: R32.2, U8.60 (BOOT0)
unnamed: R31.2, U8.7 (NRST)
unnamed: R33.2, U8.27 (PB1)
unnamed: R34.2, U8.28 (PB2)

## Commit log

2023-07-18 初次提交
2023-08-03 已打样测试两版，第三版暂未修改
